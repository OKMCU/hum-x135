# Keil uVision project hum-x135.uvproj, settings and files
target hum-x135 (MCS-51)
  device: N76E003 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0x2FF) CLOCK(16000000)
  output: hum-x135 +hex
  c include: ..\lib\bufmgr;..\lib\stdlib;..\lib\stringx;..\hal;..\app;..\main;..\osal;..\osal\portable;..\spl;..\spl\fwlib;..\osal\portable\heapmgr
  link misc: REMOVEUNUSED
  group LIB
    ../lib/bufmgr/: bufmgr.c
    ../lib/stringx/: stringx.c
    ../lib/stdlib/: stdstr.c
  group SPL
    ../spl/: STARTUP.A51 spl_mcu.c spl_uart.c spl_interrupt.c spl_adc.c spl_sysclk.c spl_timer.c
  group HAL
    ../hal/: hal_assert.c hal_cli.c hal_drivers.c hal_mcu.c hal_key.c hal_mist.c hal_led.c hal_freqdet.c hal_waterdet.c hal_light.c
  group OSAL
    ../osal/: osal_fifo.c osal_msg.c osal_system.c osal_task.c osal_timer.c
  group OSAL\PORTABLE
    ../osal/portable/: osal_port.c
  group APP
    ../app/: app_assert.c app_event_main.c app_info.c app_task_main.c app_task_cli.c app_event_cli.c app_task_key.c app_event_key.c app_event_fhop.c app_task_fhop.c app_event_waterdet.c app_task_waterdet.c
  group MAIN
    ../main/: main.c
